FILESEXTRAPATHS_prepend := "${THISDIR}/mesa-demos:"
SRC_URI_append_zynqmp = "file://0001-Revert-eglinfo-Add-EXT_platform_-awareness.patch"
